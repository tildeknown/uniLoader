## configs/agassi2_defconfig
```kconfig
CONFIG_COMPRESS_GZIP=y
CONFIG_UART_DEBUG=y
CONFIG_SIMPLE_FB=y
CONFIG_HI6250=y
CONFIG_HUAWEI_AGASSI2=y
```
